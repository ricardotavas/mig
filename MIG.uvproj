# Keil uVision project MIG.uvproj, settings and files
target LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MIG +hex
  AfterMake: fromelf --bincombined --bincombined_base=0x10000 --output=obj\MIG.bin obj\MIG.axf
  c flags: Optim=1
  c define: ITFUDP ITFUART0 ITFUART1 ITFUSB MIG
  c include: .\Dep;.\Keil;.\USB
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000 size 0x70000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group WEB
    N:/Projetos LPC17xx/PROJECT/LPC176x_MIG/V02_12_MEGA/Web/: Web.inp Web.c index.htm pg_header.inc pg_footer.inc xml_http.js ver.cgi network.cgi system.cgi tcp.cgi update.cgi dir.cgi dirREL.cgi
    ./Web/: help.htm pg_header2.inc format.cgi dirSYS.cgi dirUPD.cgi dep.cgi seldep.cgi ticket.cgi design.cgi uploadbin.cgi uploadbmp.cgi userbox.cgi callnext.cgi callnext.cgx real.cgi real.cgx
  group USB
    ./USB/: usbcfg.h usbcore.c usbdesc.c usbhw.c usbuser.c hiduser.c
  group APP
    ./: App.c REPORT.c DataFlash.c
    N:/Projetos LPC17xx/PROJECT/LPC176x_MIG/V02_12_MEGA/: QUEUE.c
  group FILES KEIL
    ./Keil/: Net_Config.c File_Config.c HTTP_CGI.c HTTP_uif.c HTTP_err.c fs_time.c Retarget.c
    N:/Projetos LPC17xx/KEIL4_12/DRIVERS/: EMAC_LPC17xx.c
  group LIB KEIL
    ../../../KEIL4_12/LIBS/: TCP_CM3.lib FS_CM3.lib
  group FILES WYMA
    ./Dep/: IAP_CONFIG.c SPI_CONFIG.c UART_CONFIG.c IMP_CONFIG.c RTC_CONFIG.c COMM_CONFIG.c PWM.c USERCOMM.c CRC16.c TIMER1.c
  group LIB WYMA
    ../../../LIBRARY/LPC176x_IAP/V01/Obj/: LPC176xIAP.lib
    ../../../LIBRARY/LPC176x_UART/V01/Obj/: LPC176xUART.lib
    ../../../LIBRARY/LPC176x_SPI/V02/Obj/: LPC176xSPI.lib
    ./Dep/: LPC176xCOMM.lib
    ../../../LIBRARY/LPC176x_IMP/V02_R03/Obj/: LPC176xIMP.lib
    ../../../LIBRARY/LPC176x_RTC/V04/Obj/: LPC176xRTC.lib
  group DOC
    ./: leiame.txt
